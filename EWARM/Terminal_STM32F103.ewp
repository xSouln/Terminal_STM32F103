# IAR project Terminal_STM32F103.ewp, settings and files
configuration Terminal_STM32F103 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; pattern_stm32f4xx
  ICCARM.CCIncludePath2: ../Core/Inc; $STM32CubRepositorys$/STM32Cube_FW_F1_V1.6.1/Drivers/STM32F1xx_HAL_Driver/Inc; $STM32CubRepositorys$/STM32Cube_FW_F1_V1.6.1/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; $STM32CubRepositorys$/STM32Cube_FW_F1_V1.6.1/Drivers/CMSIS/Device/ST/STM32F1xx/Include; $STM32CubRepositorys$/STM32Cube_FW_F1_V1.6.1/Drivers/CMSIS/Include; $xLibMcrocontrollers$/; $xLibMcrocontrollers$/Macroses; $xLibMcrocontrollers$/Patterns; $xLibMcrocontrollers$/Bootloaders/STM32F4xx; ../Sources; ../Sources/Interfaces
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Terminal_STM32F103.hex
  ILINK.IlinkOutputFile: Terminal_STM32F103.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: adc.c gpio.c i2c.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c usart.c
  group Application/User/Interfaces
    ../Sources/Interfaces/: Usart1.c Usart1.h
  group Application/User/Sources
    ../Sources/: Bootloader.c Bootloader.h Ports.c Ports.h Responses.c Responses.h
  group Application/User/xLibMcrocontrollers
    $xLibMcrocontrollers$/: xConverter.c xConverter.h xList.c xList.h xPort.h xRx.c xRx.h xTask.c xTask.h xThread.c xThread.h xTimer.c xTimer.h xTransaction.c xTransaction.h xTx.c xTx.h xType.h
  group Application/User/xLibMcrocontrollers/Macroses
    $xLibMcrocontrollers$/Macroses/: xMacroses.h
  group Application/User/xLibMcrocontrollers/Patterns
    $xLibMcrocontrollers$/Patterns/: pattern_stm32f4xx_i2c.h pattern_stm32f4xx_spi.h pattern_stm32f4xx_uart.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    $STM32CubRepositorys$/STM32Cube_FW_F1_V1.6.1/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
